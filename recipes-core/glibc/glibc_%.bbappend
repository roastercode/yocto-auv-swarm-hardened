# CVE-2010-4756 : faux positif connu — concerne glob() mais n'est pas
# considéré comme une vulnérabilité exploitable par l'équipe glibc                                                                                                                         
CVE_STATUS[CVE-2010-4756] = "ignored: False positive, not considered a vulnerability by upstream glibc"